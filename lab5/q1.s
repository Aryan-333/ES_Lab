		AREA RESET, DATA, READONLY
		EXPORT __Vectors		
__Vectors
		DCD 0X10001000
		DCD Reset_Handler
		ALIGN
		AREA mycode, CODE, READONLY
		ENTRY
		EXPORT Reset_Handler
Reset_Handler
		LDR R0,=ARRAY
		LDR R1,=RESULT
		MOV R2,#5
GO	LDR R3,[R0],#4
		STR R3,[R1],#1
		SUBS R2,#1
		BNE GO
		LDR R0,=RESULT
		MOV R1,R0
		MOV R3,#5
BRANCH1		MOV R5,R1
		LDRB R4,[R1],#1
		MOV R2,R1
		SUBS R3,#1
		MOV R7,R3
BRANCH2		LDRB R6,[R2]
		CMP R6,R4
		BCC UP
		B CONT
UP	MOV R5,R2
CONT	ADD R2,#1
		SUBS R7,#1
		BNE BRANCH2
		LDR R6,[R5]
		STRB R6,[R1,#-1]
		STRB R4,[R5]
		CMP R3,#1
		BNE BRANCH1	
STOP	B STOP
ARRAY DCD 4,2,9,4,1
	AREA mydata, DATA, READWRITE
RESULT DCD 0
		END